# Keil uVision project Lab1.uvproj, settings and files
target Lab1 (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output
  c flags: Optim=1
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./: main.c
  group lib
    C:/ValvanoWare/driverlib/rvmdk/: driverlib.lib
